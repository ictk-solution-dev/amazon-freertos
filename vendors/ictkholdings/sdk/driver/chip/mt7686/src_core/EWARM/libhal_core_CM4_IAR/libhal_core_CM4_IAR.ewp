# IAR project libhal_core_CM4_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO; PRODUCT_VERSION=7686
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: inc; ..\..\..\..\inc; ..\..\..\inc; ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\..\kernel\service\syslog\inc; W:\Documents\2523_dev\gva\middleware\MTK\minicli\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: libhal_core_CM4_IAR.bin
  ILINK.IlinkOutputFile: i2c_communication_with_EEPROM_polling.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group src_core
    ../../: hal_efuse.c hal_sleep_manager.c hal_sleep_manager_internal.c hal_spm.c
