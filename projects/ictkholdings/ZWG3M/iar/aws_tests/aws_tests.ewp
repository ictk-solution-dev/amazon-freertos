# IAR project aws_tests.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023,Pe021
  ICCARM.IExtraOptions: -DUNITY_INCLUDE_CONFIG_H; -DAMAZON_FREERTOS_ENABLE_UNIT_TESTS; -DMBEDTLS_THREADING_C; -DMBEDTLS_THREADING_ALT; -DIOT_TEST_MQTT_MOSQUITTO=1
  ICCARM.PreInclude: ..\..\..\..\..\vendors\ictkholdings\boards\ZWG3M\aws_tests\application_code\ictkholdings_code\include\global.h
  ICCARM.CCIncludePath2: ..\..\..\..\..\vendors\ictkholdings\boards\ZWG3M\aws_tests\config_files; ..\..\..\..\..\vendors\ictkholdings\boards\ZWG3M\aws_tests\application_code\mediatek_code\include; ..\..\..\..\..\vendors\ictkholdings\boards\ZWG3M\aws_tests\application_code\ictkholdings_code\include; ..\..\..\..\..\freertos_kernel\include; ..\..\..\..\..\tests\include; ..\..\..\..\..\libraries\c_sdk\standard\common\include; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\board\mt7686_hdk\ept\inc; ..\..\..\..\..\libraries\3rdparty\unity\src; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\libraries\3rdparty\tracealyzer_recorder\Include; ..\..\..\..\..\vendors\ictkholdings\boards\ZWG3M\aws_tests\FlashMT7686.mac; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\chip\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\chip\mt7686\inc; ..\..\..\..\..\libraries\abstractions\wifi\include; ..\..\..\..\..\libraries\freertos_plus\standard\utils\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\nvdm\inc; ..\..\..\..\..\demos\dev_mode_key_provisioning\include; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\board\mt7686_hdk\util\inc; ..\..\..\..\..\libraries\3rdparty\pkcs11; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\connsys\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\lwip\ports\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\lwip\src\include; ..\..\..\..\..\libraries\abstractions\platform\freertos\include; ..\..\..\..\..\libraries\abstractions\platform\include; ..\..\..\..\..\libraries\3rdparty\CMock\vendor\unity\extras\fixture\src; ..\..\..\..\..\libraries\3rdparty\CMock\vendor\unity\extras\memory\src; ..\..\..\..\..\libraries\abstractions\secure_sockets\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\ping\inc; ..\..\..\..\..\libraries\c_sdk\standard\common\include\private; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\src; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\dhcpd\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\libraries\3rdparty\jsmn; ..\..\..\..\..\libraries\3rdparty\lwip\src\include; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\chip\mt7686\src\common\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\minicli\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\verno\inc; ..\..\..\..\..\demos\dev_mode_key_provisioning\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\mbedtls\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\mbedtls\configs; ..\..\..\..\..\libraries\freertos_plus\standard\crypto\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\mbedtls\include\mbedtls; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\nvdm\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\prebuilt\middleware\MTK\wifi_stack\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\connsys\src; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\aws_iot\samples\freertos; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\aws_iot\tests\freertos_integration\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\aws_iot\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\lwip\ports\include\arch; ..\..\..\..\..\libraries\3rdparty\mbedtls\include\mbedtls; ..\..\..\..\..\libraries\abstractions\wifi\test; ..\..\..\..\..\libraries\abstractions\secure_sockets\include; ..\..\..\..\..\libraries\freertos_plus\standard\tls\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\ping\inc; ..\..\..\..\..\freertos_kernel\portable\IAR\ARM_CM4F; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\chip\mt7686\inc; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\test\access; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\test\mock; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\src\private; ..\..\..\..\..\libraries\c_sdk\standard\common\include; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\ictk\g3\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\aws_iot\platform\freertos; ..\..\..\..\..\libraries\freertos_plus\standard\tls\test; ..\..\..\..\..\libraries\c_sdk\aws\shadow\src; ..\..\..\..\..\libraries\c_sdk\aws\shadow\include; ..\..\..\..\..\libraries\c_sdk\standard\serializer\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\port_service\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\atci\inc; ..\..\..\..\..\libraries\3rdparty\mbedtls_utils; ..\..\..\..\..\libraries\3rdparty\unity\extras\fixture\src; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\ictk\pkcs11; ..\..\..\..\..\vendors\ictkholdings\sdk\kernel\service\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\kernel\service\syslog\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\kernel\extend\inc; ..\..\..\..\..\freertos_kernel\portable\IAR\ARM_CM4F; ..\..\..\..\..\vendors\ictkholdings\boards\ZWG3M\ports\pkcs11\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\..\..\vendors\ictkholdings\boards\ZWG3M\aws_tests\config_files\; ..\..\..\..\..\libraries\3rdparty\unity\src
  OBJCOPY.OOCOutputFile: aws_tests.bin
  ILINK.IlinkOutputFile: aws_tests.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: ..\..\..\..\..\vendors\ictkholdings\boards\ZWG3M\aws_tests\flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree; -f ..\..\..\..\..\vendors\ictkholdings\sdk\prebuilt\middleware\MTK\wifi_stack\rom\e2\symboldef_link.h
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group application_code
    ../../../../../vendors/ictkholdings/boards/ZWG3M/aws_tests/application_code/mediatek_code/source/: lwipopts.c
    ../../../../../vendors/ictkholdings/boards/ZWG3M/aws_tests/application_code/: main.c
    ../../../../../vendors/ictkholdings/boards/ZWG3M/aws_tests/application_code/ictkholdings_code/source/: test_print.c
  group aws
    ../../../../../demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
    ../../../../../libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_network_freertos.c
  group freertos_kernel
    ../../../../../freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../freertos_kernel/portable/MemMang/: heap_4.c
    ../../../../../freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../vendors/ictkholdings/sdk/kernel/extend/src/: wrap_heap.c
  group g3
    ../../../../../vendors/ictkholdings/sdk/driver/ictk/g3/src/: cqueue.c g3_api.cpp g3_api_depend_function.cpp g3_command.c g3_etc_util.cpp g3_handle_port.c g3_i2c.c g3_nvdm_config .c g3_semaphore.c g3_tls_setup.c i2c_sw.c ictk_util.c puf_if.c
  group iar_library
    ../../../../../vendors/ictkholdings/sdk/driver/chip/mt7686/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/nvdm/lib/: libnvdm_CM4_IAR.a
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/wifi_service/combo/lib/wifi_inic/: libwifi_CM4_IAR.a
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/wifi_stack/lib/: libwifi_ram_CM4_repeater_wps_IAR.a
  group iot_taskpool
    ../../../../../libraries/freertos_plus/standard/utils/src/: iot_pki_utils.c
    ../../../../../libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group json
    ../../../../../libraries/c_sdk/standard/serializer/src/: iot_json_utils.c
    ../../../../../libraries/c_sdk/standard/serializer/src/json/: iot_serializer_json_decoder.c iot_serializer_json_encoder.c
  group libraries
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/ping/src/: ping.c
  group lwip
    ../../../../../libraries/3rdparty/lwip/src/core/ipv4/: acd.c autoip.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../libraries/3rdparty/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../libraries/3rdparty/lwip/src/netif/: ethernet.c
    ../../../../../libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
    ../../../../../libraries/c_sdk/standard/common/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
    ../../../../../libraries/3rdparty/jsmn/: jsmn.c
  group mbedtls/common
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/mbedtls/library/common/: util.c
  group mbedtls/ictk
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/mbedtls/source/ictk/: aes_interface.c ecdsa_interface.c pkparse_interface.c profile.c ssl_cli_interface.c ssl_tls_interface.c x509write_crt_interface.c x509write_csr_interface.c
  group mbedtls/src-3rdparty
    ../../../../../libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/src-vendor
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/mbedtls/library/: aes.c aria.c asn1write.c chacha20.c chachapoly.c cipher_wrap.c ctr_drbg.c ecdsa.c ecp.c entropy_hardware_poll.c md.c md_wrap.c net_sockets.c pem.c pk.c pk_wrap.c poly1305.c rsa.c sha256.c ssl_ciphersuites.c ssl_cli.c ssl_srv.c ssl_tls.c x509.c x509_crt.c x509_csr.c
  group mbedtls/utils
    ../../../../../libraries/3rdparty/mbedtls/utils/: mbedtls_utils.c
  group mediatek_code/atci
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/atci/src/: mediatek_atci.a
  group mediatek_code/cli
    ../../../../../vendors/ictkholdings/boards/ZWG3M/aws_tests/application_code/mediatek_code/source/: mediatek_cli.a
  group mediatek_code/connsys
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/connsys/src/: mediatek_connsys.a
  group mediatek_code/dhcpd
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/dhcpd/src/: mediatek_dhcpd.a
  group mediatek_code/drivers
    ../../../../../vendors/ictkholdings/sdk/driver/chip/mt7686/src/: mediatek_hal_driver.a
  group mediatek_code/lwip_thirdparty
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/lwip/src/core/ipv4/: dhcp.c
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/lwip/ports/: ethernetif.c sys_arch.c
  group mediatek_code/mediatek_kernel
    ../../../../../vendors/ictkholdings/sdk/kernel/service/src/: mediatek_kernel_service.a
    ../../../../../vendors/ictkholdings/sdk/kernel/rtos/FreeRTOS/Source/portable/IAR/mt7686/: port_tick.a
    ../../../../../vendors/ictkholdings/sdk/kernel/service/syslog/src/: syslog.a
  group mediatek_code/mt7686
    ../../../../../vendors/ictkholdings/boards/ZWG3M/aws_tests/application_code/mediatek_code/source/: mediatek_mt7686.a
  group mediatek_code/network_config
    ../../../../../vendors/ictkholdings/boards/ZWG3M/aws_tests/application_code/mediatek_code/source/: mediatek_network_config.a
  group mediatek_code/nvdm
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/nvdm/src/: mediatek_nvdm.a
  group mediatek_code/port_service
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/port_service/src/: mediatek_portservice.a
  group mediatek_code/pwr
    ../../../../../vendors/ictkholdings/sdk/driver/board/mt7686_hdk/pwr/: mt768x_default_PerRate_TxPwr.c
  group mediatek_code/util
    ../../../../../vendors/ictkholdings/sdk/driver/board/mt7686_hdk/util/src/: mediatek_util.a
  group mediatek_code/wifi_driver
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/wifi_service/combo/src/: mediatek_wifi.a
  group mqtt
    ../../../../../libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group pkcs
    ../../../../../vendors/ictkholdings/sdk/driver/ictk/pkcs11/: g3_pkcs11.c iot_pkcs11.c iot_pkcs11_mbedtls.c iot_pkcs11_pal.c
  group ports
    ../../../../../vendors/ictkholdings/boards/ZWG3M/ports/crypto/: iot_crypto.c
    ../../../../../libraries/c_sdk/standard/common/test/: iot_memory_leak.c
    ../../../../../libraries/abstractions/platform/freertos/: iot_metrics.c iot_threads_freertos.c
    ../../../../../vendors/ictkholdings/boards/ZWG3M/ports/secure_sockets/: iot_secure_sockets.c
    ../../../../../libraries/freertos_plus/standard/utils/src/: iot_system_init.c
    ../../../../../vendors/ictkholdings/boards/ZWG3M/ports/tls/: iot_tls.c
    ../../../../../vendors/ictkholdings/boards/ZWG3M/ports/wifi/: iot_wifi.c
  group shadow
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/aws_iot/src/: aws_iot_shadow.c aws_iot_shadow_actions.c aws_iot_shadow_json.c aws_iot_shadow_records.c
    ../../../../../libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c
  group tests
    ../../../../../libraries/c_sdk/aws/shadow/test/unit/: aws_iot_tests_shadow_api.c aws_iot_tests_shadow_parser.c
    ../../../../../libraries/c_sdk/aws/shadow/test/system/: aws_iot_tests_shadow_system.c
    ../../../../../tests/common/: aws_test.c aws_test_framework.c aws_test_runner.c iot_test_freertos.c iot_tests_network.c
    ../../../../../libraries/c_sdk/aws/shadow/test/: aws_test_shadow.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/access/: iot_test_access_mqtt_api.c iot_test_access_mqtt_subscription.c
    ../../../../../libraries/freertos_plus/standard/crypto/test/: iot_test_crypto.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/: iot_test_mqtt_agent.c
    ../../../../../libraries/abstractions/pkcs11/test/: iot_test_pkcs11.c
    ../../../../../libraries/abstractions/secure_sockets/test/: iot_test_tcp.c
    ../../../../../libraries/freertos_plus/standard/tls/test/: iot_test_tls.c
    ../../../../../libraries/abstractions/wifi/test/: iot_test_wifi.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/unit/: iot_tests_mqtt_api.c iot_tests_mqtt_metrics.c iot_tests_mqtt_receive.c iot_tests_mqtt_subscription.c iot_tests_mqtt_validate.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/system/: iot_tests_mqtt_system.c
    ../../../../../libraries/c_sdk/standard/common/test/: iot_tests_taskpool.c
  group unity
    ../../../../../libraries/3rdparty/unity/src/: unity.c
    ../../../../../libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c
